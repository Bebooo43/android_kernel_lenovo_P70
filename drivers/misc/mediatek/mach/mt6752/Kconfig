## drivers/misc/mediatek/mach/mt6752/Kconfig
```kconfig
config CPU_OC
	bool "CPU_OVERCLOCK"
	default n
	help
	  Overclock MT6752 to 2 GHz
```
